# Keil uVision project PocketCarTV0.1.uvprojx, settings and files
target PcarTV0.1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: PocketCarTV0.1 +hex
  c flags: Optim=1 wLevel=2
  c include: .\User;.\Lib\ADC;.\Lib\Interrupt;.\Lib\LibBackup;.\Lib\Motor;.\Lib\mpu6050;.\Lib\PWM;.\Lib\SystemTime;.\Lib\Ultrasonic;.\Lib\USART
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group OnChip
    ./Lib/USART/: USART.cpp Interrupt.cpp
    ./Lib/PWM/: F103_PWM.cpp
    ./Lib/ADC/: F103_ADC_S.cpp
    ./Lib/Ultrasonic/: GPIO.cpp
    ./Lib/mpu6050/: I2C.cpp
  group OffChip
    ./Lib/Ultrasonic/: UltrasonicInt.cpp Ultrasonic.cpp stm32f10xInt.cpp Exti.cpp
    ./Lib/Motor/: motor.cpp
    ./Lib/mpu6050/: mpu6050.cpp
  group ToolBox
    ./Lib/mpu6050/: Delay.cpp
  group App
    ./User/: Transmission.h main.cpp CtrlDir.cpp part.h PressureModel.cpp function.cpp
    ./Lib/ADC/: Voltage.cpp
  group System
    ./Lib/SystemTime/: TaskManager.cpp
  group Class
    ./User/: DataClass.h Coordinate.cpp Coordinate.h
software components: CMSIS:CORE 3.40.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:ADC 3.5.0, Device:StdPeriph Drivers:DMA 3.5.0, Device:StdPeriph Drivers:EXTI 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:I2C 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
